options:
  parameters:
    author: KJ6DZB
    category: Custom
    comment: First working shared-baseband one-channel test flowgraph
    description: RTL-SDR shared baseband with one WBFM demod branch
    generate_options: qt_gui
    id: shared_baseband_one_channel
    output_language: python
    title: Shared Baseband One Channel
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: chan1_cutoff
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: chan1_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: chan1_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,4,1,2
    label: Receiver Offset (+/-50 kHz)
    orient: Qt.Horizontal
    rangeType: int
    start: '-50000'
    step: '1000'
    stop: '50000'
    value: '0'
  states: {}
- name: chan1_transition
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: gain_mode0
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: gain_mode0_control
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,2
    label: RF Gain Mode
    label0: Manual
    label1: Automatic
    num_opts: '2'
    option1: 'True'
    options: '[False, True]'
    orient: Qt.QHBoxLayout
    type: raw
    value: gain_mode0
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,2
    label: PPM Correction
    orient: Qt.Horizontal
    rangeType: int
    start: '-100'
    step: '1'
    stop: '150'
    value: '135'
  states: {}
- name: rf_center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,2,1,2
    label: RF Center Frequency (Hz)
    type: real
    value: '90700000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,2
    label: RF Gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/chan1_decim
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '""'
    samp_rate: audio_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: chan1_offset
    decim: chan1_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, chan1_cutoff, chan1_transition)
    type: ccf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"numchan=1 rtl=0"'
    bb_gain0: '20'
    corr0: ppm
    freq0: rf_center_freq
    gain0: rf_gain
    gain_mode0: gain_mode0
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 0,0,1,2
    label: Shared Baseband FFT (relative)
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/chan1_decim
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 2,0,1,2
    label: Receiver 1 Branch FFT
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,0,1,2
    name: Shared Baseband Waterfall (relative)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
