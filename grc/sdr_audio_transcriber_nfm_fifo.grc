options:
  parameters:
    author: Mathison Ott / ChatGPT
    category: '[SDR-audio-Transcriber]'
    comment: NFM receiver monitor that writes mono s16le PCM to runtime/grc_audio.pcm FIFO for scripts/start_grc_clip_writer.sh
    description: RTL-SDR/Osmocom NFM acquisition with QT spectrum/waterfall/audio monitor and FIFO PCM output for clip_writer.py.
    generate_options: qt_gui
    id: sdr_audio_transcriber_nfm_fifo
    output_language: python
    title: SDR Audio Transcriber NFM FIFO
  states: {}

blocks:
- name: rf_samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 442.275e6
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '-41'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: fifo_path
  id: variable
  parameters:
    value: '"runtime/grc_audio.pcm"'
  states: {}
- name: audio_gain
  id: variable
  parameters:
    value: '0.85'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"numchan=1"'
    bb_gain0: '20'
    center_freq0: center_freq
    corr0: ppm
    freq_corr0: ppm
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rf_samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    color1: blue
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    label1: RF Spectrum
    name: '"RF Spectrum"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    intensity: '0.6'
    name: '"RF Waterfall"'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: '5000'
    quad_rate: rf_samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fifo_path
    type: short
    unbuffered: 'True'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', analog_nbfm_rx_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
